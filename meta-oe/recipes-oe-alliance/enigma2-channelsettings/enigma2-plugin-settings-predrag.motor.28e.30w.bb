SUMMARY = "Predr@d  motor 28e - 30w"

SETTINGS_FILENAME = "predrag.motor.28e.30w"

include oe-alliance-settings.inc
